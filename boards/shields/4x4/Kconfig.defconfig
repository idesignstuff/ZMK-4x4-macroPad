## boards/shields/4x4/Kconfig.shield
```kconfig
config SHIELD_4X4
    def_bool $(shields_list_contains,4x4)
    select ADC
    select GPIO
```
